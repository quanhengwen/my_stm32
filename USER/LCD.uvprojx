# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\ZLG_GUI;..\HARDWARE\spi_flash;..\HARDWARE\SPI;..\TEXT;..\HARDWARE\Menu;..\HARDWARE\KEY;..\HARDWARE;..\MALLOC;..\APP;..\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../APP/: weather.c BeiJtime.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: LI9341.c
    ../HARDWARE/spi_flash/: fatfs_flash_spi.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/Menu/: miltimenu.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/: crc.c timer.c air302.c gpio.c cJSON.c utf8togbk.c rtc.c
    ./: pic.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../TEXT/: fontupd.c
    ../SYSTEM/: fifo.c kfifo.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group ZLG_GUI
    ../ZLG_GUI/: ConvertColor.c font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C lcmdrv.c loadbit.c menu.c spline.c windows.c CONFIG.h GUI_CONFIG.H
  group MQTT
    ../MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group MALLOC
    ../MALLOC/: malloc.c
  group README
    ../: README.TXT
